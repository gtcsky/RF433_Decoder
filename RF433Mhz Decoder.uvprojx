# Keil uVision project RF433Mhz Decoder.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: Target +hex
  AfterMake: fromelf --vhx --32x1 -o .\Objects\Target.bin .\Objects\Target.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\USER\inc;.\Communication\inc;.\FWLB\inc;.\DEVICE
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group DEVICE
    ./DEVICE/: system_cx32l003.c startup_cx32l003.s
  group FWLB
    ./FWLB/src/: cx32l003_adc.c cx32l003_advtim.c cx32l003_awk.c cx32l003_beeper.c cx32l003_clktrim.c cx32l003_crc.c cx32l003_debug.c cx32l003_exti.c cx32l003_flash.c cx32l003_gpio.c cx32l003_i2c.c cx32l003_it.c cx32l003_iwdt.c cx32l003_lptimer.c cx32l003_lpuart.c cx32l003_lvd.c cx32l003_owire.c cx32l003_pca.c cx32l003_rcc.c cx32l003_rtc.c cx32l003_spi.c cx32l003_syscon.c cx32l003_timer.c cx32l003_uart.c cx32l003_vc.c cx32l003_wwdt.c misc.c
  group USER
    ./USER/src/: user_advtime.c user_basetime.c user_exti.c user_internalFlash.c user_lptimer.c user_SysClock.c main.c user_menu.c user_adc.c user_awk.c user_iwdt .c user_ddl.c user_uart.c user_lightEffect.c user_key.c user_tone.c communication.c
  group DOC
    ./DOC/: readme.txt
software components: CMSIS:CORE 5.0.0
